# Keil uVision project DSP_LiB.uvprojx, settings and files
target FRDM-K64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: DSP_LiB
  c flags: Optim=4
  c include: C:\Freescale\KSDK_1.2.0\platform\CMSIS\Include;C:\Freescale\KSDK_1.2.0\platform\devices\MK64F12;.\drivers;.\RTE\Device\MK64FN1M0xxx12\include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group src
    ./src/: bpdenoise.h
    ./: delay_intr.c
  group drivers
    ./drivers/: delay.c gpio.c i2c.c i2s.c audio.c dma.c
  group Startup
    ./RTE/Device/MK64FN1M0xxx12/: system_MK64F12.c startup_MK64F12.s
software components: CMSIS:DSP 1.4.2
